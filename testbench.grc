options:
  parameters:
    author: iracigt
    generate_options: qt_gui
    id: testbench
    output_language: python
    run_options: run
    title: Testbench
  states: {}

blocks:
- name: act_taps
  id: variable
  parameters:
    value: '[x * 2**-15 for x in tx_taps_hex]'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: '[+0.70711 + +0.70711j, +1.0 + +0.0j, -1.0 + +0.0j, -0.70711 + -0.70711j, +0.0 + +1.0j, +0.70711 + -0.70711j, -0.70711 + +0.70711j, -0.0 + -1.0j]'
    dims: '1'
    precision: '8'
    rot_sym: '8'
    soft_dec_lut: '''auto'''
    sym_map: list(range(0,8))
    type: calcdist
  states: {}
- name: decim
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ideal_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(int(sps), samp_rate, symbol_rate, rolloff, ntaps)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: '31'
  states: {}
- name: quant_taps
  id: variable
  parameters:
    value: '[round(2**15 * x) / 2**15 for x in ideal_taps]'
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), rolloff, int(sym_per_arm*sps*nfilts))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_samp_rate / decim
  states: {}
- name: sps
  id: variable
  parameters:
    value: float(samp_rate) / symbol_rate
  states: {}
- name: sym_per_arm
  id: variable
  parameters:
    value: '8'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 20e3
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '70'
  states: {}
- name: tx_taps_hex
  id: variable
  parameters:
    value: '[119, -19, -111, 129, 21, -277, 199, 446, -619, -616, 1385, 760, -3014, -857, 10233, 17209, 10233, -857, -3014, 760, 1385, -616, -619, 446, 199, -277, 21, 129, -111, -19, 119]'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-3.8 * (1+1j)'
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /mnt/hgfs/iracigt/Desktop/packets_floats.bin
    type: float
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: /Users/iracigt/Desktop/packets_ldpc.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_3_0
  id: blocks_file_sink
  parameters:
    file: /Users/iracigt/Desktop/packets_bin.bin
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/iracigt/Developer/DVB_hat/hdl/iq_bytes.bin
    length: ''
    offset: 0 * 21690 * 2
    repeat: 'True'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 2**-12
    type: complex
  states: {}
- name: blocks_not_xx_0_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(sps)
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '1'
    sps: '1'
    symbols: '[0.707+0.707j, 0.707-0.707j, -0.707-0.707j, -0.707+0.707j, 0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j, 0.707+0.707j, 0.707-0.707j, 0.707+0.707j, -0.707+0.707j, -0.707-0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j, -0.707-0.707j, -0.707+0.707j, -0.707-0.707j, -0.707+0.707j, 0.707+0.707j, -0.707+0.707j, 0.707+0.707j, -0.707+0.707j, -0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j, 0.707+0.707j, -0.707+0.707j, 0.707+0.707j, -0.707+0.707j, -0.707-0.707j, -0.707+0.707j, -0.707-0.707j, -0.707+0.707j, -0.707-0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j, -0.707-0.707j, -0.707+0.707j, -0.707-0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j, 0.707+0.707j, -0.707+0.707j, 0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j, -0.707-0.707j, 0.707-0.707j, -0.707-0.707j, -0.707+0.707j, -0.707-0.707j, -0.707+0.707j, -0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j, -0.707-0.707j, 0.707-0.707j, -0.707-0.707j, 0.707-0.707j, -0.707-0.707j, -0.707+0.707j, 0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j, -0.707-0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j, -0.707-0.707j, -0.707+0.707j, 0.707+0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j, 0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j, 0.707+0.707j, 0.707-0.707j, -0.707-0.707j, -0.707+0.707j]'
    threshold: thresh / 90
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel
    damping: '1.0'
    loop_bw: 2*numpy.pi / 100 * 0.6
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: act_taps
    type: ccc
  states: {state: disabled}
- name: kc2qol_dvbs2_8psk_demod_0
  id: kc2qol_dvbs2_8psk_demod
  parameters:
    phase_tag: None
  states: {}
- name: kc2qol_dvbs2_pl_deframer_0
  id: kc2qol_dvbs2_pl_deframer
  parameters:
    code: '0'
    packet_len: '21600'
    start_tag: pmt.intern('corr_est')
  states: {}
- name: kc2qol_ldpc_decoder_fb_0
  id: kc2qol_ldpc_decoder_fb
  parameters: {}
  states: {}
- name: note_0
  id: note
  parameters:
    note: pmt.intern('phase_est')
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,2,1)
    label1: Reclocked
    marker1: '2'
    name: '"EVM Constellation"'
    size: '1024'
    type: complex
    update_time: '0.001'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: (3,0,1,2)
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: (0,1,2,1)
    size: '1024'
    srate: samp_rate
    tr_delay: '512 / samp_rate '
    tr_level: thresh
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: '"phase_est"'
    type: float
    ymax: '50'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    tr_delay: '512 / samp_rate '
    tr_level: '20'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"phase_est"'
    type: float
  states: {state: disabled}

connections:
- [blocks_add_const_vxx_0, '0', blocks_repeat_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_not_xx_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_3, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_file_sink_3_0, '0']
- [blocks_repeat_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_not_xx_0_0, '0']
- [digital_corr_est_cc_0, '0', blocks_null_sink_0, '0']
- [digital_corr_est_cc_0, '0', kc2qol_dvbs2_pl_deframer_0, '0']
- [digital_corr_est_cc_0, '1', blocks_complex_to_mag_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_corr_est_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [kc2qol_dvbs2_8psk_demod_0, '0', kc2qol_ldpc_decoder_fb_0, '0']
- [kc2qol_dvbs2_8psk_demod_0, '0', qtgui_time_sink_x_0_0, '0']
- [kc2qol_dvbs2_pl_deframer_0, '0', kc2qol_dvbs2_8psk_demod_0, '0']
- [kc2qol_ldpc_decoder_fb_0, '0', blocks_repack_bits_bb_0, '0']

metadata:
  file_format: 1
