options:
  parameters:
    author: iracigt
    generate_options: qt_gui
    id: fir_siggen
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: act_taps
  id: variable
  parameters:
    value: '[x * 2**-15 for x in tx_taps_hex]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: tx_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, 2, 1, 0.2, 31)
  states: {}
- name: tx_taps_exp
  id: variable
  parameters:
    value: '[-0.001129150390625, -0.009796142578125, -0.018341064453125, -0.025115966796875, -0.028533935546875, -0.027191162109375, -0.020172119140625, -0.00714111328125, 0.01141357421875, 0.0343017578125, 0.0596923828125, 0.08526611328125, 0.108551025390625, 0.127197265625, 0.139251708984375, 0.143402099609375, 0.143402099609375, 0.139251708984375, 0.127197265625, 0.108551025390625, 0.08526611328125, 0.0596923828125, 0.0343017578125, 0.01141357421875, -0.00714111328125, -0.020172119140625, -0.027191162109375, -0.028533935546875, -0.025115966796875, -0.018341064453125, -0.009796142578125, -0.001129150390625]'
  states: {}
- name: tx_taps_hex
  id: variable
  parameters:
    value: '[226, -36, -211, 246, 40, -527, 379, 850, -1179, -1172, 2637, 1447, -5739, -1633, 19484, 32767, 19484, -1633, -5739, 1447, 2637, -1172, -1179, 850, 379, -527, 40, 246, -211, -36, 226]'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: 64+64j
    type: complex
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-4 * (1+1j)'
    type: complex
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/iracigt/Developer/DVB_hat/hdl/fir_in_u8.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /Users/iracigt/Developer/DVB_hat/hdl/fir_correct_u16.bin
    type: short
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/iracigt/Developer/DVB_hat/hdl/iq_bytes.bin
    length: ''
    offset: 0 * 21690 * 2
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2**-8
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 2**-12
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '32'
    type: complex
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: '2'
    type: complex
  states: {state: bypassed}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: '[1, 1]'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: tx_taps_hex
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_stream_mux_0, '1']
- [analog_noise_source_x_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_add_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_complex_to_interleaved_char_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_interleaved_char_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_add_const_vxx_0, '0']
- [blocks_repeat_1, '0', blocks_complex_to_interleaved_char_0, '0']
- [blocks_stream_mux_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_throttle_0, '0', blocks_repeat_1, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [interp_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
