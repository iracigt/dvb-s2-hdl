options:
  parameters:
    author: iracigt
    generate_options: qt_gui
    id: sim_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1279e6
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: '[+0.70711 + +0.70711j, +1.0 + +0.0j, -1.0 + +0.0j, -0.70711 + -0.70711j, +0.0 + +1.0j, +0.70711 + -0.70711j, -0.70711 + +0.70711j, -0.0 + -1.0j]'
    dims: '1'
    precision: '8'
    rot_sym: '8'
    soft_dec_lut: '''auto'''
    sym_map: list(range(0,8))
    type: calcdist
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * 2
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-3.8 * (1+1j)'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/iracigt/Developer/DVB_hat/hdl/iq_bytes.bin
    length: ''
    offset: 0 * 21690 * 2
    repeat: 'True'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 2**-12
    type: complex
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel
    damping: '1.0'
    loop_bw: 2*3.14159 / 100 * 0.6
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '2'
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: 60 - tx_gain
    auto_filter: 'True'
    bandwidth: '2000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: int(center_freq)
    samplerate: int(samp_rate)
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,2,1)
    label1: Reclocked
    marker1: '2'
    name: '"EVM Constellation"'
    size: '1024'
    type: complex
    update_time: '0.001'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_add_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0, '0']

metadata:
  file_format: 1
